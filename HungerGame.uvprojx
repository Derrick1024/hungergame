# Keil uVision project HungerGame.uvprojx, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HungerGame +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,
  c include: ..\software;.\delay;.\TIM3_pwm;.\TIM4_pwm;.\usart;.\RTE;.\RTE\Device;.\RTE\Device\STM32F103RC;.\PS2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ./: main.c stm32f10x_it.c
  group TIM
    ./TIM3_pwm/: TIM3_pwm_output.c
    ./TIM4_pwm/: TIM4_pwm_output.c
  group usart
    ./usart/: bsp_usart1.c
  group delay
    ./delay/: systick_delay.c
  group PS2
    ./PS2/: PS2.c
software components: CMSIS:CORE 4.1.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
